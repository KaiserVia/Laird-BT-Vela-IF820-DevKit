# Keil uVision project sism.uvprojx, settings and files
target sism (5040082::V5.04 update 2 (build 82)::.\ARMCC_504u2)
  device: LPC1768 NXP
  pack: Keil.LPC1700_DFP.2.0.0
  cpu: IRAM(0x10000000,0x8000) IRAM2(0x2007C000,0x8000) IROM(0x00000000,0x80000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: sism
  AfterMake: C:\Keil_v5\ARM\ARMCC\bin\fromelf.exe --bin --output sism.bin .\Objects\sism.axf
  AfterMake: C:\Keil_v5\ARM\ARMCC\bin\fromelf.exe --i32 --output sism.hex .\Objects\sism.axf
  c flags: Optim=3 v6Lang=1 v6LangP=1 wLevel=2
  memory RVCT4: ROM 0x0 size 0x80000
  memory RVCT9: RAM 0x10000000 size 0x8000
  memory RVCT10: RAM 0x2007c000 size 0x8000
  scatter file: .\Objects\sism.sct
  group src
    ./sprachen/: sictxt.c
    ./: main.c hard.c libtool.c i2cm.c fio.c flash.c ramcode.c sicom.c sio.c sictst.c USB_tools.c rtc.c measure.c xmodem.c btio.c gsmio.c mqtt.c gpsio.c
  group Header
    ./: sictxt.h
  group sprachen
    ./sprachen/: sictxt_d-f-i.c sictxt_d-f-pl.c sictxt_e-cz-sl.c sictxt_e-es-i.c sictxt_e-es-pt.c sictxt_e-f-nl.c
software components: CMSIS:CORE 3.40.0, CMSIS:RTOS:Keil RTX 4.75.0, File System:CORE 6.2.0, File System:Drive:USB 6.2.0, USB:CORE 6.2.0, USB:Device 6.2.0, USB:Device:CDC 6.2.0, USB:Host 6.2.0, USB:Host:MSC 6.2.0, CMSIS Driver:I2C 2.01, CMSIS Driver:USB Device 2.00, CMSIS Driver:USB Host 2.00, Device:GPDMA 1.00, Device:GPIO 1.00, Device:PIN 1.00, Device:Startup 1.0.0
